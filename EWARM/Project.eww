<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F103C8_SX1262_IAR.ewp</path>
  </project>
  <batchBuild />
</workspace>
